# Keil uVision project ARM32.uvprojx, settings and files
target ARM32 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\App_Common;.\App_Modbus;.\Arm_Kernel;.\Drv_Common;.\Drv_Modbus;.\Gd32_Hal;.\Gd32_Hal\Include;.\Mid_Modbus;.\Mid_Modbus\rtu;.\Mid_Modbus\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App_Common
    ./App_Common/: main.c update.c
  group Drv_Common
    ./Drv_Common/: delay.c gd32f30x_it.c systick.c rs485_drv.c flash_drv.c
  group Gd32_Hal
    ./Gd32_Hal/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_dma.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_fmc.c
  group Arm_Kernel
    ./Arm_Kernel/: system_gd32f30x.c startup_gd32f30x_hd.s
software components: Compiler:I/O:STDERR 1.2.0
