# Keil uVision project ARM32.uvprojx, settings and files
target ARM32 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM32 +hex
  AfterMake: fromelf --text -a -c --output .\Objects\ARM32.dis .\Objects\ARM32.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\App_Common;.\App_Modbus;.\Arm_Kernel;.\Drv_Common;.\Drv_Modbus;.\Gd32_Hal;.\Gd32_Hal\Include;.\Mid_Modbus;.\Mid_Modbus\rtu;.\Mid_Modbus\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App_Common
    ./App_Common/: hmi_app.c main.c sensor_app.c store_app.c picture.c
  group App_Modbus
    ./App_Modbus/: modbus_app.c
  group Mid_Modbus
    ./Mid_Modbus/: mb.c modbus_slave.c
    ./Mid_Modbus/rtu/: mbcrc.c mbrtu.c
    ./Mid_Modbus/functions/: mbfuncholding.c mbutils.c
  group Drv_Common
    ./Drv_Common/: delay.c gd32f30x_it.c key_drv.c led_drv.c ntc_drv.c queue.c rh_drv.c rtc_drv.c sensor_drv.c systick.c usb2Com_drv.c eeprom_drv.c lcd_drv.c touch_drv.c fonts_ascii.c fonts_chinese.c
  group Drv_Modbus
    ./Drv_Modbus/: portevent.c portserial.c porttimer.c
  group Gd32_Hal
    ./Gd32_Hal/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_dma.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_exmc.c
  group Arm_Kernel
    ./Arm_Kernel/: system_gd32f30x.c startup_gd32f30x_hd.s
software components: Compiler:I/O:STDERR 1.2.0
