# Keil uVision project GPIO_LED_HAL.uvprojx, settings and files
target GPIO_LED_HAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPIO_LED_HAL +hex
  AfterMake: fromelf --text -a -c --output=all.dis Objects\ARM32.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\App;.\Driver;.\Arm;.\GD32_Hal;.\GD32_Hal\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./App/: main.c
  group Driver
    ./Driver/: delay.c delay.h led_drv.c led_drv.h key_drv.c key_drv.h gd32f30x_it.c systick.c systick.h
  group GD32_Hal
    ./GD32_Hal/Source/: gd32f30x_gpio.c gd32f30x_rcu.c gd32f30x_misc.c
    ../2.10 基于内核DWT实现硬件延时/GD32_Hal/Source/: gd32f30x_exti.c
  group Arm
    ./Arm/: startup_gd32f30x_hd.s system_gd32f30x.c
