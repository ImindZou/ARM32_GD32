# Keil uVision project ARM32.uvprojx, settings and files
target ARM32 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\App;.\Arm;.\Driver;.\GD32_Hal;.\GD32_Hal\Include;.\App_Modbus;.\Mid_Modbus;.\Mid_Modbus\rtu;.\Drv_Modbus;.\Mid_Modbus\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./App/: main.c hmi_app.c sensor_app.c
  group Driver
    ./Driver/: key_drv.c gd32f30x_it.c led_drv.c systick.c usb2Com_drv.c queue.c delay.c rtc_drv.c sensor_drv.c ntc_drv.c rh_drv.c
  group GD32_Hal
    ./GD32_Hal/Source/: gd32f30x_gpio.c gd32f30x_rcu.c gd32f30x_misc.c gd32f30x_usart.c gd32f30x_rtc.c gd32f30x_pmu.c gd32f30x_bkp.c gd32f30x_adc.c gd32f30x_dma.c gd32f30x_timer.c
  group Arm
    ./Arm/: startup_gd32f30x_hd.s system_gd32f30x.c
  group App_Modbus
    ./App_Modbus/: modbus_app.c
  group Drv_Modbus
    ./Drv_Modbus/: portevent.c portserial.c porttimer.c
  group Mid_Modbus
    ./Mid_Modbus/: mb.c modbus_slave.c
    ./Mid_Modbus/rtu/: mbcrc.c mbrtu.c
    ./Mid_Modbus/functions/: mbfuncholding.c mbutils.c
software components: Compiler:I/O:STDERR 1.2.0
