# Keil uVision project ARM32.uvprojx, settings and files
target ARM32 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.3
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM32 +hex
  AfterMake: fromelf --text -a -c --output .\Objects\ARM32.dis .\Objects\ARM32.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\App_Common;.\App_Modbus;.\Arm_Kernel;.\Drv_Common;.\Drv_Modbus;.\Gd32_Hal;.\Gd32_Hal\Include;.\Mid_Modbus;.\Mid_Modbus\rtu;.\Mid_Modbus\include;\Mid_Lvgl;.\Mid_Lvgl\driver\porting;.\Mid_Lvgl\src;.\Mid_Lvgl\src\core;.\Mid_Lvgl\src\draw;.\Mid_Lvgl\src\extra;.\Mid_Lvgl\src\extra\layouts;.\Mid_Lvgl\src\extra\layouts\flex;.\Mid_Lvgl\src\extra\layouts\grid;.\Mid_Lvgl\src\extra\themes;.\Mid_Lvgl\src\extra\themes\basic;.\Mid_Lvgl\src\extra\themes\default;.\Mid_Lvgl\src\extra\themes\mono;.\Mid_Lvgl\src\extra\widgets;.\Mid_Lvgl\src\extra\widgets\animimg;.\Mid_Lvgl\src\extra\widgets\calendar;.\Mid_Lvgl\src\extra\widgets\chart;.\Mid_Lvgl\src\extra\widgets\colorwheel;.\Mid_Lvgl\src\extra\widgets\imgbtn;.\Mid_Lvgl\src\extra\widgets\keyboard;.\Mid_Lvgl\src\extra\widgets\led;.\Mid_Lvgl\src\extra\widgets\list;.\Mid_Lvgl\src\extra\widgets\menu;.\Mid_Lvgl\src\extra\widgets\meter;.\Mid_Lvgl\src\extra\widgets\msgbox;.\Mid_Lvgl\src\extra\widgets\span;.\Mid_Lvgl\src\extra\widgets\spinbox;.\Mid_Lvgl\src\extra\widgets\spinner;.\Mid_Lvgl\src\extra\widgets\tabview;.\Mid_Lvgl\src\extra\widgets\tileview;.\Mid_Lvgl\src\extra\widgets\win;.\Mid_Lvgl\src\font;.\Mid_Lvgl\src\hal;.\Mid_Lvgl\src\misc;.\Mid_Lvgl\src\widgets;.\App_Hmi\widgets;.\App_Hm.\App_Common;.\App_Modbus;.\Arm_Kernel;.\Drv_Common;.\Drv_Modbus;.\Gd32_Hal;.\Gd32_Hal\Include;.\Mid_Modbus;.\Mid_Modbus\rtu;.\Mid_Modbus\include;.\Mid_Lvgl;.\Mid_Lvgl\driver\porting;.\Mid_Lvgl\src;.\Mid_Lvgl\src\core;.\Mid_Lvgl\src\draw;.\Mid_Lvgl\src\extra;.\Mid_Lvgl\src\extra\layouts;.\Mid_Lvgl\src\extra\layouts\flex;.\Mid_Lvgl\src\extra\layouts\grid;.\Mid_Lvgl\src\extra\themes;.\Mid_Lvgl\src\extra\themes\basic;.\Mid_Lvgl\src\extra\themes\default;.\Mid_Lvgl\src\extra\themes\mono;.\Mid_Lvgl\src\extra\widgets;.\Mid_Lvgl\src\extra\widgets\animimg;.\Mid_Lvgl\src\extra\widgets\calendar;.\Mid_Lvgl\src\extra\widgets\chart;.\Mid_Lvgl\src\extra\widgets\colorwheel;.\Mid_Lvgl\src\extra\widgets\imgbtn;.\Mid_Lvgl\src\extra\widgets\keyboard;.\Mid_Lvgl\src\extra\widgets\led;.\Mid_Lvgl\src\extra\widgets\list;.\Mid_Lvgl\src\extra\widgets\menu;.\Mid_Lvgl\src\extra\widgets\meter;.\Mid_Lvgl\src\extra\widgets\msgbox;.\Mid_Lvgl\src\extra\widgets\span;.\Mid_Lvgl\src\extra\widgets\spinbox;.\Mid_Lvgl\src\extra\widgets\spinner;.\Mid_Lvgl\src\extra\widgets\tabview;.\Mid_Lvgl\src\extra\widgets\tileview;.\Mid_Lvgl\src\extra\widgets\win;.\Mid_Lvgl\src\font;.\Mid_Lvgl\src\hal;.\Mid_Lvgl\src\misc;.\Mid_Lvgl\src\widgets;.\App_Hmi;.\App_Hmi\widgets;.\App_Hmi\widgets\assets
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App_Common
    ./App_Common/: main.c sensor_app.c store_app.c
  group App_Modbus
    ./App_Modbus/: modbus_app.c
  group App_Hmi
    ./App_Hmi/: hmi_app.c humiimg.c tempimg.c humi_temphumi.c
  group Mid_Modbus
    ./Mid_Modbus/: mb.c modbus_slave.c
    ./Mid_Modbus/rtu/: mbcrc.c mbrtu.c
    ./Mid_Modbus/functions/: mbfuncholding.c mbutils.c
  group Drv_Common
    ./Drv_Common/: delay.c gd32f30x_it.c key_drv.c led_drv.c ntc_drv.c queue.c rh_drv.c rtc_drv.c sensor_drv.c systick.c usb2Com_drv.c eeprom_drv.c lcd_drv.c touch_drv.c exsram_drv.c
  group Drv_Modbus
    ./Drv_Modbus/: portevent.c portserial.c porttimer.c
  group Gd32_Hal
    ./Gd32_Hal/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_dma.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_exmc.c
  group Arm_Kernel
    ./Arm_Kernel/: system_gd32f30x.c startup_gd32f30x_hd.s
  group Mid_lvgl/core
    ./Mid_lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Mid_lvgl/draw
    ./Mid_lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ./Mid_lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group Mid_lvgl/extra
    ./Mid_lvgl/src/extra/layouts/flex/: lv_flex.c
    ./Mid_lvgl/src/extra/layouts/grid/: lv_grid.c
    ./Mid_lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ./Mid_lvgl/src/extra/themes/default/: lv_theme_default.c
    ./Mid_lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ./Mid_lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ./Mid_lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ./Mid_lvgl/src/extra/widgets/chart/: lv_chart.c
    ./Mid_lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ./Mid_lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ./Mid_lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ./Mid_lvgl/src/extra/widgets/led/: lv_led.c
    ./Mid_lvgl/src/extra/widgets/list/: lv_list.c
    ./Mid_lvgl/src/extra/widgets/menu/: lv_menu.c
    ./Mid_lvgl/src/extra/widgets/meter/: lv_meter.c
    ./Mid_lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ./Mid_lvgl/src/extra/widgets/span/: lv_span.c
    ./Mid_lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ./Mid_lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ./Mid_lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ./Mid_lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ./Mid_lvgl/src/extra/widgets/win/: lv_win.c
    ./Mid_lvgl/src/extra/: lv_extra.c
  group Mid_lvgl/font
    ./Mid_lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_font_semibold_26.c lv_font_semibold_28.c lv_font_semibold_40.c
  group Mid_lvgl/hal
    ./Mid_lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Mid_lvgl/misc
    ./Mid_lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Mid_lvgl/widgets
    ./Mid_lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Mid_lvgl/driver
    ./Mid_lvgl/driver/porting/: lv_port_disp.c lv_port_indev.c
software components: Compiler:I/O:STDERR 1.2.0
